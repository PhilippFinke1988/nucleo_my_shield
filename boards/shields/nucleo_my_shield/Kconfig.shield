## boards/shields/nucleo_my_shield/Kconfig.shield
```kconfig
config SHIELD_NUCLEO_MY_SHIELD
  def_bool $(shields_list_contains,nucleo_my_shield)
```
